<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\USB_to_Serial.ewp</path>
  </project>
  <batchBuild />
</workspace>
